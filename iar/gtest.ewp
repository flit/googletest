# IAR project gtest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 Freescale MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: GTEST_OS_BARE_METAL=1; GTEST_HAS_CLONE=0; GTEST_HAS_EXCEPTIONS=0; GTEST_HAS_GLOBAL_STRING=0; GTEST_HAS_GLOBAL_WSTRING=0; GTEST_HAS_POSIX_RE=0; GTEST_HAS_PTHREAD=0; GTEST_HAS_RTTI=0; GTEST_HAS_STD_WSTRING=1; GTEST_HAS_TR1_TUPLE=0; GTEST_HAS_SEH=0; GTEST_HAS_STREAM_REDIRECTION=0; GTEST_USE_OWN_TR1_TUPLE=1; GTEST_LANG_CXX11=0; GTEST_LINKED_AS_SHARED_LIBRARY=0; GTEST_CREATE_SHARED_LIBRARY=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../include; ../samples; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../samples/: sample1.cc sample1_unittest.cc sample2.cc sample2_unittest.cc sample3_unittest.cc
  group gtest
    ../src/: gtest-death-test.cc gtest-filepath.cc gtest-internal-inl.h gtest-port.cc gtest-printers.cc gtest-test-part.cc gtest-typed-test.cc gtest.cc gtest_main.cc
